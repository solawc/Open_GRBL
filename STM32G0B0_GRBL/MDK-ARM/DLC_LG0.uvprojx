# Keil uVision project DLC_LG0.uvprojx, settings and files
target DLC_LG0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G0B0CETx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20023FFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: DLC_LG0 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3
  c define: USE_HAL_DRIVER,STM32G0B0xx
  c misc: --diag_suppress=1295,1035,111
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\Drivers\HAL_Driver;..\..\Common\grbl;..\..\Common\grbl\grbl_task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7f800
  memory RVCT9: RAM 0x20000000 size 0x24000
  group Application/MDK-ARM
    ./: startup_stm32g0b0xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_cec.c stm32g0xx_hal_comp.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_cryp.c stm32g0xx_hal_cryp_ex.c stm32g0xx_hal_dac.c stm32g0xx_hal_dac_ex.c stm32g0xx_hal_fdcan.c stm32g0xx_hal_hcd.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_i2s.c stm32g0xx_hal_irda.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_lptim.c stm32g0xx_hal_pcd.c stm32g0xx_hal_pcd_ex.c stm32g0xx_hal_rng.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_smartcard.c stm32g0xx_hal_smartcard_ex.c stm32g0xx_hal_smbus.c stm32g0xx_hal_smbus_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_usart.c stm32g0xx_hal_usart_ex.c stm32g0xx_hal_wwdg.c stm32g0xx_ll_adc.c stm32g0xx_ll_comp.c stm32g0xx_ll_crc.c stm32g0xx_ll_crs.c stm32g0xx_ll_dac.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_i2c.c stm32g0xx_ll_lptim.c stm32g0xx_ll_lpuart.c stm32g0xx_ll_pwr.c stm32g0xx_ll_rng.c stm32g0xx_ll_rtc.c stm32g0xx_ll_spi.c stm32g0xx_ll_tim.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_usart.c stm32g0xx_ll_usb.c stm32g0xx_ll_utils.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/HAL_Drivers
    ../Drivers/HAL_Driver/: grbl_hal.c hal_gpio.c hal_uart.c hal_tim.c hal_flash_eeprom.c hal_spi.c hal_w25qxx.c
  group grbl
    ../../Common/grbl/: coolant_control.c eeprom.c gcode.c jog.c limits.c main.c motion_control.c nuts_bolts.c planner.c print.c probe.c protocol.c report.c serial.c settings.c spindle_control.c stepper.c system.c
    ../../Common/grbl/grbl_task/: grbl_main.c
software components: CMSIS:CORE 4.3.0
