# Keil uVision project STM32F4_GRBL.uvprojx, settings and files
target STM32F4_GRBL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F4_GRBL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --diag_suppress=1295,1035,111
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\App\grbl\grbl_task;..\Drivers\HAL_Driver;..\..\Common\grbl;..\..\Common\fatfs\src;..\..\Common\grbl\grbl_task;..\..\Common\freeRTOS\src\include;..\..\Common\freeRTOS\src\portable\MemMang;..\..\Common\freeRTOS\app;..\..\Common\freeRTOS\src\include;..\..\Common\freeRTOS\src\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/HAL_Driver
    ../Drivers/HAL_Driver/: grbl_hal.c hal_flash_eeprom.c hal_gpio.c hal_i2c.c hal_uart.c hal_spi.c hal_tim.c hal_w25qxx.c
  group App/grbl
    ../../Common/grbl/: coolant_control.c eeprom.c gcode.c jog.c limits.c main.c motion_control.c nuts_bolts.c planner.c print.c probe.c protocol.c report.c serial.c settings.c spindle_control.c stepper.c system.c
  group App/grbl/task
    ../../Common/grbl/grbl_task/: grbl_main.c
  group App/freeRTOS/src
    ../../Common/freeRTOS/src/: croutine.c list.c event_groups.c queue.c stream_buffer.c tasks.c timers.c
  group App/freeRTOS/port
    ../../Common/freeRTOS/src/portable/MemMang/: heap_4.c
    ../../Common/freeRTOS/src/portable/RVDS/ARM_CM4F/: port.c
  group App/freeRTOS/app
    ../../Common/freeRTOS/app/: led_task.c
  group App/fatfs
    ../../Common/fatfs/src/: diskio.c ff.c
    ../../Common/fatfs/src/option/: cc936.c
software components: CMSIS:CORE 4.3.0
